# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8S5897 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0x0000-0x0FFF) CLOCK(16000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\..\..\..\Libary\StdDriver\inc;..\..\..\..\Libary\Device\CMS8S6990\Include
  link misc: REMOVEUNUSED
  group CMS
    ../../../../Libary/Device/CMS8S6990/Include/: cms8s6990.h
    ../../../../Libary/Device/CMS8S6990/: STARTUP_CMS8S6990.A51
  group LIB
    ../../../../Libary/StdDriver/src/: spi.c
  group User
    ../code/: isr.c main.c demo_spi.c
