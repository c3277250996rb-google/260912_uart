# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: USE_FORMULA
  c include: ..\code;..\..\..\..\Libary\StdDriver\inc;..\..\..\..\Libary\Device\CMS8S6990\Include
  link misc: REMOVEUNUSED
  group CMS
    ../../../../Libary/Device/CMS8S6990/Include/: cms8s6990.h
    ../../../../Libary/Device/CMS8S6990/: startup_cms8s6990.A51
  group LIB
    ../../../../Libary/StdDriver/src/: gpio.c uart.c timer.c
  group User
    ../code/: isr.c main.c demo_uart.c
